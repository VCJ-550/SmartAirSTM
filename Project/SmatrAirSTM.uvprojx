# Keil uVision project SmatrAirSTM.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SmatrAirSTM +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\Cortex-M3\CMSIS;..\Cortex-M3\CORE;..\Cortex-M3\FLIW\inc;..\User;..\BspLibrary\System\sys;..\BspLibrary\System\delay;..\BspLibrary\System\usart;..\BspLibrary\System\IIC;..\BspLibrary\System\ADC;..\BspLibrary\System\SPI;..\BspLibrary\System\TIMER;..\BspLibrary\Hardweare\LED;..\BspLibrary\Hardweare\KEY;..\BspLibrary\Hardweare\Power;..\BspLibrary\Hardweare\HDC1080;..\BspLibrary\Hardweare\BH1750;..\BspLibrary\Hardweare\LCD;..\BspLibrary\Hardweare\TOUCH;..\BspLibrary\Hardweare\W25QXX;..\BspLibrary\Hardweare\Tuya;..\BspLibrary\Hardweare\Tuya\mcu_sdk;..\BspLibrary\Hardweare\Sensor;..\Application\LcdShow;..\Application\BordSet;..\Application\App;..\BspLibrary\Hardweare\TEXT
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CMSIS
    ../Cortex-M3/CMSIS/: stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../Cortex-M3/CORE/: core_cm3.c startup_stm32f10x_hd.s
  group STMLib
    ../Cortex-M3/FLIW/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group BSP/System
    ../BspLibrary/System/sys/: sys.c
    ../BspLibrary/System/delay/: delay.c
    ../BspLibrary/System/usart/: usart.c
    ../BspLibrary/System/IIC/: IIC.c
    ../BspLibrary/System/ADC/: adc.c
    ../BspLibrary/System/TIMER/: timer.c
    ../BspLibrary/System/SPI/: spi.c
  group BSP/Hardweared
    ../BspLibrary/Hardweare/LED/: led.c
    ../BspLibrary/Hardweare/KEY/: key.c
    ../BspLibrary/Hardweare/Power/: power.c
    ../BspLibrary/Hardweare/HDC1080/: hdc.c
    ../BspLibrary/Hardweare/BH1750/: bh1750.c
    ../BspLibrary/Hardweare/LCD/: lcd.c lcd_init.c pic.c
    ../BspLibrary/Hardweare/TOUCH/: touch.c
    ../BspLibrary/Hardweare/W25QXX/: exw25q128.c
    ../BspLibrary/Hardweare/Tuya/: wbr.c
    ../BspLibrary/Hardweare/Sensor/: Sensor.c
    ../BspLibrary/Hardweare/TEXT/: fontupd.c text.c
  group BSP/Tuya
    ../BspLibrary/Hardweare/Tuya/mcu_sdk/: mcu_api.c protocol.c system.c
  group Application
    ../Application/LcdShow/: show.c
    ../Application/BordSet/: bord.c
    ../Application/App/: app.c
  group USER
    ../User/: main.c
